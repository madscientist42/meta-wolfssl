require recipes-wolfssl/wolftpm/commercial/wolftpm-commercial.inc

require ${WOLFTPM_REQUIRE}