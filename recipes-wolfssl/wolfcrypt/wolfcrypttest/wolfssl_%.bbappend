# Don't need the package check function on a pure GPL build...
DO_DELTASK = "1"

require wolfcrypttest.inc