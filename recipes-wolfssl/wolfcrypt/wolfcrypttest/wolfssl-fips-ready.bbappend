require wolfcrypttest.inc