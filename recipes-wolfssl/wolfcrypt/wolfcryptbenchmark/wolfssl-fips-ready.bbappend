require wolfcryptbenchmark.inc